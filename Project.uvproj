# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: main.c
  group app
    ./: I2C.c I2C.h AT24C02.c AT24C02.h DHT11.c DHT11.h DS1302.c DS1302.h KEY.c KEY.h LCD1602.c LCD1602.h Delay.c Delay.h Relay.c Relay.h Timer0.c Timer0.h UART.c UART.h Time.c Time.h
