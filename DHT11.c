#include <REGX52.H>

//引脚定义
sbit DHT11=P2^4;	//温湿度模块的数据线接在P2^4引脚上

//用数组存储接收到的数据
unsigned char DHT11Data[5]={0};

/**
  * @brief	DHT11延时私有函数，延时20ms@11.0592MHz
  * @param	无
  * @retval	
  */
void DHT11_Delay20ms(void)
{
	unsigned char i,j;

	i = 36;
	j = 217;
	do
	{
		while(--j);
	} while(--i);
}

/**
  * @brief	DHT11初始化
  * @param	无
  * @retval	返回应答位，模块存在则返回0
  */
unsigned char DHT11_Init(void)
{
	unsigned char i;
	unsigned char TimeOutFlag;	//超时标志
	unsigned char AckBit;	//应答位
	DHT11=0;
	DHT11_Delay20ms();	//Delay 20ms（范围：18ms~30ms）
	DHT11=1;
	i=23;while(--i);	//Delay 51us @11.0592MHz
	AckBit=DHT11;
	while((!DHT11)&&--TimeOutFlag);	//超时则退出while循环
	while(DHT11&&--TimeOutFlag);
	return AckBit;
}

/**
  * @brief	DHT11接收一个字节
  * @param	无
  * @retval	要接收的字节
  */
unsigned char DHT11_ReceiveByte(void)
{
	unsigned char Byte=0x00;
	unsigned char i,j;
	unsigned char TimeOutFlag;
	
  	for(j=0;j<8;j++)
	{
		TimeOutFlag=100;
		while(!DHT11&&--TimeOutFlag);
		if(TimeOutFlag==0)break;	//超时则退出for循环
		i=15;while(--i);	//拉高34us
		if(DHT11){Byte|=(0x80>>j);}
		TimeOutFlag=100;
		while(DHT11&&--TimeOutFlag);
		if(TimeOutFlag==0)break;	//超时则退出for循环
	}
	return Byte;
}

/**
  * @brief	DHT11读取5个字节的数据
  * @param	无
  * @retval	返回读数是否正确的标志位，1：正确，0：错误
  */
unsigned char DHT11_ReadData(void)
{
	unsigned char i;
	unsigned char DHTFlag;
	DHT11_Init();
	EA=0;	//单总线时序不能被打断，如果用到中断，需要暂时关闭中断
	for(i=0;i<5;i++)
	{
		DHT11Data[i]=DHT11_ReceiveByte();
	}
	EA=1;	//重新开启中断
	i=23;while(--i);	//Delay 51us
	if(DHT11Data[0]+DHT11Data[1]+DHT11Data[2]+DHT11Data[3]==DHT11Data[4])
	{DHTFlag=1;}
	else{DHTFlag=0;}
	return DHTFlag;
}

